## drivers/input/fingerprint/fpc/Kconfig
```kconfig
config FINGERPRINT_FPC
	default n
       bool "FPC_BTP fingerprint sensor support"
```
